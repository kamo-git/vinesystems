# Repository kamo-git/vinesystems

File README.md:

# vinesystems

https://vinesystems.net/ で使用しているプログラムとか回路図とか置いています。

## KiCad design esp32/Aideepen_ESP32/Aideepen_ESP32.kicad_pcb

File esp32/README.md:

# esp32
ESP32 Demo Program

ブログで公開しているサンプルプログラムをGitHubにも置いときます

Parts:
C1: 0.1u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
J1: Conn_01x05_Female; PinHeader_1x05_P2.54mm_Vertical
J2, J3: Conn_01x15_Female; PinHeader_1x15_P2.54mm_Vertical

Connections:
+3.3V: J1.1, J3.15
+5V: J2.15
/EN: C1.1, J2.1
/GPIO1: J3.3
/GPIO2: J3.12
/GPIO3: J3.4
/GPIO4: J3.11
/GPIO5: J3.8
/GPIO12: J2.12
/GPIO13: J2.13
/GPIO14: J2.11
/GPIO15: J3.13
/GPIO16: J3.10
/GPIO17: J3.9
/GPIO18: J3.7
/GPIO19: J3.6
/GPIO21: J1.2, J3.5
/GPIO22: J1.3, J3.2
/GPIO23: J3.1
/GPIO25: J2.8
/GPIO26: J2.9
/GPIO27: J2.10
/GPIO32: J2.6
/GPIO33: J2.7
/GPIO34: J2.4
/GPIO35: J2.5
/GPIO36: J2.2
/GPIO39: J2.3
GND: C1.2, J1.5, J2.14, J3.14

Notes on the sheet:
SHT35 I2C通信用
ESP32 DevLit V1
リセット失敗回避用

Board: 2 copper layers, 45.1 x 43.2 mm, 4 parts (3 on the bottom side), 5 nets.

## Commit log

2022-12-29 ESP32追加
